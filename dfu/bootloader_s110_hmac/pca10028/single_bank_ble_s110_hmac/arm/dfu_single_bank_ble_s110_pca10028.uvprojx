# Keil uVision project dfu_single_bank_ble_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SHA2_USE_INTTYPES_H BYTE_ORDER=LITTLE_ENDIAN
  c misc: --c99
  c include: ..\..\..\config\dfu_dual_bank_ble_s110_pca10028;..\..\..\config;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\..\components\libraries\bootloader_dfu\ble_transport;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\new_files
  library: MicroLIB
  memory RVCT4: ROM 0x3b000 size 0x5000
  memory RVCT9: RAM 0x20002c00 size 0x5380
  memory RVCT10: RAM 0x20007f80 size 0x80
  group Application
    ../../../: dfu_ble_svc.c main.c
  group HMAC
    ../../../new_files/: hmac_sha256.c sha2.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../components/libraries/bootloader_dfu/: bootloader.c bootloader_settings_arm.c bootloader_util_arm.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble.c dfu_single_bank.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../modified_files/: dfu_init_hmac_sha256.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.40.0, Device:Startup 7.1.0
